# Keil uVision project IAP_Dataflash_EEPROM_SPROM_Array.uvproj, settings and files
target IAP_Dataflash_EEPROM_SPROM_Array (MCS-51)
  device: MS51DA9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: UART0 +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: IAP_EEPROM_SPROM.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c uart.c common.c eeprom_sprom.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
