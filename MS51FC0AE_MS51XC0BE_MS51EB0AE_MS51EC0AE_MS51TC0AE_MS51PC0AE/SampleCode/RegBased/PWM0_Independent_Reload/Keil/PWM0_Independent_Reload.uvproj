# Keil uVision project PWM0_Independent_Reload.uvproj, settings and files
target RegBased (MCS-51)
  device: ML51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: PWM0_Independent_Reload +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: PWM0_Independent_Reload.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c common.c delay.c pwm0.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
