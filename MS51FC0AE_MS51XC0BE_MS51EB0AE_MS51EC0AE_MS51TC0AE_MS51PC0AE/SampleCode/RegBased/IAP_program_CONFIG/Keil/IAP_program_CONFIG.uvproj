# Keil uVision project IAP_program_CONFIG.uvproj, settings and files
target IAP_program_CONFIG (MCS-51)
  device: MS51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: IAP_program_CONFIG +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: IAP_program_CONFIG.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c IAP.c common.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
