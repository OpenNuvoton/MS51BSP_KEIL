# Keil uVision project UART0_Interrupt_RW.uvproj, settings and files
target Target 1 (MCS-51)
  device: MS51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: UART0_Interrupt_RW +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: UART0_RW.C
  group Library
    ../../../../Library/StdDriver/src/: sys.c uart.c common.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
