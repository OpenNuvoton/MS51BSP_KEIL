# Keil uVision project UART1_Printf.uvproj, settings and files
target UART1_Printf (MCS-51)
  device: MS51DA9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: UART1_Printf +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: Print_UART1.C PUTCHAR.C
  group Library
    ../../../../Library/StdDriver/src/: uart.c timer.c sys.c common.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
