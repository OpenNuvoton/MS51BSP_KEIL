# Keil uVision project I2C_Slave_Interrupt.uvproj, settings and files
target I2C_Slave_Interrupt (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: I2C_Slave_Interrupt +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: I2C_S.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c common.c i2c.c eeprom.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
