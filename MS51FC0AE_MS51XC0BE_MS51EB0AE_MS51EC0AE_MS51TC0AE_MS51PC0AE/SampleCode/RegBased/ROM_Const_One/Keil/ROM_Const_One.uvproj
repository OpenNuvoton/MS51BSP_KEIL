# Keil uVision project ROM_Const_One.uvproj, settings and files
target ROM_Const_One (MCS-51)
  device: MS51DA9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: ROM_const_One +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: ROM_Const_One.C
  group Library
    ../../../../Library/StdDriver/src/: uart.c sys.c delay.c common.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
