# Keil uVision project BOD_Interrupt.uvproj, settings and files
target RegBased (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: BOD_Interrupt +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=1 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: BOD_INT.C
  group Library
    ../../../../Library/StdDriver/src/: common.c sys.c bod.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
