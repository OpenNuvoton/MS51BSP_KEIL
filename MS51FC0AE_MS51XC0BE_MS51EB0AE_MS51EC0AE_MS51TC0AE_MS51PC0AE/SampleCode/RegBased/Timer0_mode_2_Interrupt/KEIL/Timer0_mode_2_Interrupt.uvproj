# Keil uVision project Timer0_mode_2_Interrupt.uvproj, settings and files
target Timer01_M2 (MCS-51)
  device: MS51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: Timer0_mode_2_Interrupt +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: Timer0_M2.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c common.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
