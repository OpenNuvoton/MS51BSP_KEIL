# Keil uVision project I2C_EEPROM.uvproj, settings and files
target I2C_EEPROM (MCS-51)
  device: MS51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: I2C_EEPROM +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Include
  group Source
    ../: I2C_EEPROM.c
  group Common
    ../../../../Library/StdDriver/src/: sys.c uart.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
