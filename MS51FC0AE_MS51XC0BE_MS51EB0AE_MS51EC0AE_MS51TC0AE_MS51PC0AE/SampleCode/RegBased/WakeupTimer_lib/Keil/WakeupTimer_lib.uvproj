# Keil uVision project WakeupTimer_lib.uvproj, settings and files
target RegBased (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: WakeupTimer_lib +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: WKT_lib.c
  group Library
    ../../../../Library/StdDriver/src/: common.c wkt.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
