# Keil uVision project Timer1_mode_1_Interrupt.uvproj, settings and files
target Timer1_mode_1_Interrupt (MCS-51)
  device: MS51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: Timer1_mode_1_Interrupt +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: Timer1_M1.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c common.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
