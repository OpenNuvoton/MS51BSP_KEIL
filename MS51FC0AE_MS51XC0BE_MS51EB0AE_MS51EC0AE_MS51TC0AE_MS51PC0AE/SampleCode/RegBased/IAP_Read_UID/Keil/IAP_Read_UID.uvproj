# Keil uVision project IAP_Read_UID.uvproj, settings and files
target IAP_Read_UID (MCS-51)
  device: MS51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: IAP_Read_UID +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: UID_check.C
  group Library
    ../../../../Library/StdDriver/src/: sys.c uart.c IAP.c common.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
