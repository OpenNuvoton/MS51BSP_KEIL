# Keil uVision project SPI_FLASH_RW.uvproj, settings and files
target SPI_Flash_RW (MCS-51)
  device: MS51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: SpiFlash_RW +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source
    ../: SPI_Flash_RW.c
  group Common
    ../../../../Library/StdDriver/src/: spi.c common.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
