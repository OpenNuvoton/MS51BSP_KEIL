# Keil uVision project UART3_Interrupt_RW.uvproj, settings and files
target UART3_Interrupt_RW (MCS-51)
  device: MS51DA9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: UART3_Interrupt_RW +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: UART3_TX_RX.c
  group Library
    ../../../../Library/StdDriver/src/: delay.c sys.c uart3.c common.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
