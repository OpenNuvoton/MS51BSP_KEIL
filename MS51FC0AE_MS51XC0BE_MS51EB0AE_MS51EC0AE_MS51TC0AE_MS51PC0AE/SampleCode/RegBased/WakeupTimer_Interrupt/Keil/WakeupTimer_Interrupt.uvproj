# Keil uVision project WakeupTimer_Interrupt.uvproj, settings and files
target WakeupTimer_Interrupt (MCS-51)
  device: MS51DA9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: WakeupTimer_Interrupt +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: WKT_INT.c
  group Library
    ../../../../Library/StdDriver/src/: delay.c sys.c common.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
