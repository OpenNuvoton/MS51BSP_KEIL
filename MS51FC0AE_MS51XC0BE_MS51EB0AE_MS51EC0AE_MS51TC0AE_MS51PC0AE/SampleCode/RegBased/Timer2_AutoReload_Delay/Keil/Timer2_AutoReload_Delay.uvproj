# Keil uVision project Timer2_AutoReload_Delay.uvproj, settings and files
target Timer2_AutoReload_Delay (MCS-51)
  device: MS51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: Timer2 +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: Timer2_delay.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c common.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
