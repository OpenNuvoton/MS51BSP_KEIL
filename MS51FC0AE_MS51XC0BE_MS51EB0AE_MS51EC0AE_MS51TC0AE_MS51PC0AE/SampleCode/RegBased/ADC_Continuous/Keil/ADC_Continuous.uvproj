# Keil uVision project ADC_Continuous.uvproj, settings and files
target ADC (MCS-51)
  device: MS51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: ADC_Continuous +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: ADC_Continuous.c
  group Library
    ../../../../Library/StdDriver/src/: adc.c uart.c sys.c common.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
