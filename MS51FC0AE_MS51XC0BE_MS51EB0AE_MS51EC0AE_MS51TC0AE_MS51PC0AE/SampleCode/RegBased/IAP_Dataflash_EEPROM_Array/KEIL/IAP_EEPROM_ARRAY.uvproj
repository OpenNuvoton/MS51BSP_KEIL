# Keil uVision project IAP_EEPROM_ARRAY.uvproj, settings and files
target IAP (MCS-51)
  device: MS51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: IAP_ARRAY +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source Group 1
    ../: IAP_EEPROM_ARRAY.c
  group Library
    ../../../../Library/StdDriver/src/: eeprom.c uart.c sys.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
