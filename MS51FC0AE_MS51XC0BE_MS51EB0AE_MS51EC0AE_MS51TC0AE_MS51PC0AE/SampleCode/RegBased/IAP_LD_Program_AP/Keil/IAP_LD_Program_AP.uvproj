# Keil uVision project IAP_LD_Program_AP.uvproj, settings and files
target ISP_LD-AP (MCS-51)
  device: MS51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: IAP_LD_Program_AP +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: ISP_LD_AP.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c IAP.c common.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
