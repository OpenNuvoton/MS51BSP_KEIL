# Keil uVision project ADC_multi_channel.uvproj, settings and files
target ADC (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: ADC_multi_channel +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: ADC_multi.C
  group Library
    ../../../../Library/StdDriver/src/: uart.c delay.c sys.c common.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
