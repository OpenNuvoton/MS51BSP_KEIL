# Keil uVision project PWM123_library.uvproj, settings and files
target PWM123_library (MCS-51)
  device: MS51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: PWM123_library +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: PWM123_lib.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c pwm123.c common.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
