# Keil uVision project Project_temp.uvproj, settings and files
target Project_temp (MCS-51)
  device: MS51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: Project +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source Group 1
    ../: helloworld.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c uart.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
