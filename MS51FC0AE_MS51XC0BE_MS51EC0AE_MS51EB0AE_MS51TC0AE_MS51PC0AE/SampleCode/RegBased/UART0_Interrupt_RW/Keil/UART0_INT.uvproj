# Keil uVision project UART0_INT.uvproj, settings and files
target Target 1 (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: UART0 +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source Group 1
    ../: UART0_RW.C
  group Library
    ../../../../Library/StdDriver/src/: sys.c uart.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
