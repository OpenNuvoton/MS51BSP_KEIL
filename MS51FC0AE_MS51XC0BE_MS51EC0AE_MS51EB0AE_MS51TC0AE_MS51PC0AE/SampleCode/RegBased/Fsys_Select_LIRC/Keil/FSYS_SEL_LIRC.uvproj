# Keil uVision project FSYS_SEL_LIRC.uvproj, settings and files
target CLK_OUT (MCS-51)
  device: MS51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: FSYS_LIRC +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source
    ../: Fsys_LIRC.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c delay.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
