# Keil uVision project IAP_APproAP.uvproj, settings and files
target ISP_AP-AP (MCS-51)
  device: MS51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: IAP_APproAP +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source Group 1
    ../: IAP_APproAP.c
  group Common
    ../../../../Library/StdDriver/src/: sys.c delay.c IAP.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
