# Keil uVision project IAP_program_CONFIG.uvproj, settings and files
target RegBased (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: IAP_program_CONFIG +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source Group 1
    ../: IAP_program_CONFIG.c
  group Common
    ../../../../Library/StdDriver/src/: sys.c IAP.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
