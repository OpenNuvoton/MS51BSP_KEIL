# Keil uVision project INT0.uvproj, settings and files
target GPIO (MCS-51)
  device: MS51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: INT0 +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source Group 1
    ../: INT0.C
  group Common
    ../../../../Library/StdDriver/src/: sys.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
