# Keil uVision project SPI_Master_Polling.uvproj, settings and files
target SPI_M (MCS-51)
  device: N76E885 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0xFF) CLOCK(25000000)
  output: Master_P +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source
    ../: SPI_Master_Po.c
  group Common
    ../../../../Library/StdDriver/src/: sys.c spi.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
