# Keil uVision project IAP_EEPROM_ARRAY.uvproj, settings and files
target IAP (MCS-51)
  device: MS51IA9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: IAP_ARRAY +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source Group 1
    ../: IAP_EEPROM_SPROM.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c eeprom_sprom.c uart.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
