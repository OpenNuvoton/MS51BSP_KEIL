# Keil uVision project ADC_BG_VDD.uvproj, settings and files
target ADC (MCS-51)
  device: MS51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: ADC_Bandgap_VDD +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source Group 1
    ../: ADC_BG_VDD.c
  group Common
    ../../../../Library/StdDriver/src/: sys.c uart.c adc.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
