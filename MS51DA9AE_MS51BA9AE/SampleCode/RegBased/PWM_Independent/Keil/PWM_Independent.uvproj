# Keil uVision project PWM_Independent.uvproj, settings and files
target PWM (MCS-51)
  device: ML51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: PWM_Independent +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source Group 1
    ../: PWM_Independent.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c pwm.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
