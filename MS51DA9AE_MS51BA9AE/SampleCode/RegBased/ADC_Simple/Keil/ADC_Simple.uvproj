# Keil uVision project ADC_Simple.uvproj, settings and files
target ADC (MCS-51)
  device: MS51DA9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: ADC_Simple +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source Group 1
    ../: ADC_simple.C
  group Common
    ../../../../Library/StdDriver/src/: sys.c delay.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
