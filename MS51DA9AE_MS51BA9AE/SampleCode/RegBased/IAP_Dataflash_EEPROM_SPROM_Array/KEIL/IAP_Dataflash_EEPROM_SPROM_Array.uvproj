# Keil uVision project IAP_Dataflash_EEPROM_SPROM_Array.uvproj, settings and files
target IAP_Dataflash_EEPROM_SPROM_Array (MCS-51)
  device: MS51DA9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: IAP_Dataflash_EEPROM_SPROM_Array +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c eeprom_sprom.c uart.c common.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
