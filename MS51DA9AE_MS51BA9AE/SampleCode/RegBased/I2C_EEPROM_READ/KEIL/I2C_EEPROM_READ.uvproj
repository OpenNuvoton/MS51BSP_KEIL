# Keil uVision project I2C_EEPROM_READ.uvproj, settings and files
target I2C_EEPROM (MCS-51)
  device: MS51DA9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: I2C_EEPROM_READ +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: I2C_EEPROM.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c uart.c common.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
