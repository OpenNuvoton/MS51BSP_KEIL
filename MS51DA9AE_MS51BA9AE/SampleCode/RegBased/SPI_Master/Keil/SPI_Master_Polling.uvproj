# Keil uVision project SPI_Master_Polling.uvproj, settings and files
target SPI_M (MCS-51)
  device: MS51DA9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: Master_P +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source
    ../: SPI_Master_Po.c
  group Common
    ../../../../Library/StdDriver/src/: sys.c spi.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
