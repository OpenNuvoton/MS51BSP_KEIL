# Keil uVision project GPIO_Clock_Out.uvproj, settings and files
target CLK_OUT (MCS-51)
  device: MS51DA9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: GPIO_Clock_Out +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: CLK_OUT.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c common.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
