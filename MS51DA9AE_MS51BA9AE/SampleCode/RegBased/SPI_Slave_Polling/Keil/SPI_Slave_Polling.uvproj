# Keil uVision project SPI_Slave_Polling.uvproj, settings and files
target SPI_INT_M (MCS-51)
  device: MS51DA9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: SPI_S_Po +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: SPI_Slave_Polling.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c spi.c common.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
