# Keil uVision project ISP_UART1.uvproj, settings and files
target ISP_UART1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: ISP_UART0 +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source
    ../: ISP_UART1_main.c
  group Common
    ../: isp_uart1.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
