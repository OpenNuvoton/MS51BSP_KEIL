# Keil uVision project ISP_I2C.uvproj, settings and files
target Target 1 (MCS-51)
  device: ML51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: MS51_8K_I2C_ISP +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: ISP_I2C_main_autosize_wdtdis.c ISP_I2C.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
