# Keil uVision project SPI_Slave_Interrupt.uvproj, settings and files
target SPI_INT_M (MCS-51)
  device: N76E885 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0xFF) CLOCK(25000000)
  output: SPI_Slave_Interrupt +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: SPI_Slave_Int.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c spi.c common.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
