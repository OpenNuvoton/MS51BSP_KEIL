# Keil uVision project IAP_Read_UCID.uvproj, settings and files
target Target 1 (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: IAP_Read_UCID +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: UCID_check.C
  group Library
    ../../../../Library/StdDriver/src/: sys.c common.c uart.c IAP.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
