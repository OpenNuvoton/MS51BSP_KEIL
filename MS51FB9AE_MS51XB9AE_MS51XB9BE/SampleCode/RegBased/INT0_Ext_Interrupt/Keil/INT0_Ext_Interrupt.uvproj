# Keil uVision project INT0_Ext_Interrupt.uvproj, settings and files
target GPIO (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: INT0_Ext_Interrupt +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: INT0.C
  group Library
    ../../../../Library/StdDriver/src/: sys.c common.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
