# Keil uVision project printf_UART0.uvproj, settings and files
target GPIO (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: Printf_UART1 +hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source Group 1
    ../: Print_UART0.C PUTCHAR.C
  group Library
    ../../../../Library/StdDriver/src/: sys.c uart.c delay.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
