# Keil uVision project ISP_I2C.uvproj, settings and files
target GPIO (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: ISP_I2C +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source Group 1
    ../: ISP_I2C_main.c
  group Common
    ../: ISP_I2C.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
