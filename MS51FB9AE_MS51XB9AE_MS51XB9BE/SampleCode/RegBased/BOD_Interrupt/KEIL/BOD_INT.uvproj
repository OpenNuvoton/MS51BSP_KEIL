# Keil uVision project BOD_INT.uvproj, settings and files
target RegBased (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: GPIO +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=1 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source Group 1
    ../: BOD_INT.C
  group Common
    ../../../../Library/StdDriver/src/: common.c bod.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
