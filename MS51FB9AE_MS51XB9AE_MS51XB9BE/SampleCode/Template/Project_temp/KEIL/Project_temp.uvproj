# Keil uVision project Project_temp.uvproj, settings and files
target Project_temp (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: Project_temp +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c uart.c common.c bod.c delay.c eeprom.c eeprom_sprom.c i2c.c iap.c iap_sprom.c isr.c pwm.c spi.c timer.c wdt.c wkt.c adc.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
